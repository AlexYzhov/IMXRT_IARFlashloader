# IAR project Flashloader.ewp, settings and files
configuration RT1052_SphinxEVK (ARM)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6A NXP MIMXRT1052xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: SPHINX_EVK; CPU_MIMXRT1052CVL5B; NDEBUG
  ICCARM.CCIncludePath2: ..\Framework; ..\Framework\Modified; ..\Devices; ..\Drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Flashloader.srec
  ILINK.IlinkOutputFile: $CONFIG_NAME$.out
  ILINK.IlinkIcfFile: ..\FlashIMXRT1050_RAM512K.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
configuration RT1052_ShareBoard (ARM)
  as the first configuration, except:
  General.FPU2: 0
  ICCARM.CCDefines: SHAREBOARD; CPU_MIMXRT1052CVL5B; NDEBUG
configuration RT1052_IMXRT1052EVK (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: IMXRT1052_EVK; CPU_MIMXRT1052CVL5B
configuration RT1020 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: MCIMXRT1020
  group (top)
    ../: Flashloader_IMXRT.c
  group Devices
    ../Devices/: HyperFlash_S26KS512.c OctaFlash_MX25UM.c QSPI_25Q128JVSQ.c QSPI_25Q256JVEQ.c QSPI_IS25WP064.c
  group Drivers
    ../Drivers/: clock_config.c fsl_clock.c fsl_common.c fsl_flexspi.c
  group Framework
    ../Framework/: flash_loader.c flash_loader_asm.s
